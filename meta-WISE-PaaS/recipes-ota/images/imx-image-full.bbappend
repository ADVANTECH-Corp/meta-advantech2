DESCRIPTION = "FSL validation image with Advantech OTA feature"

require ota.inc
