DESCRIPTION = "TI arago base image with Advantech OTA feature"

require ota.inc
