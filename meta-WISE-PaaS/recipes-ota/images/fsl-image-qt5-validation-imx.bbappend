DESCRIPTION = "FSL QT5 validation image with Advantech OTA feature"

require ota.inc
