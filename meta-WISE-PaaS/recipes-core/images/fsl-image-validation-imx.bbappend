DESCRIPTION = "FSL validation image with Advantech EdgeSense feature"

require wise-paas.inc
