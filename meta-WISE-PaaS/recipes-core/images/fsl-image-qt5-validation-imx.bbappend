DESCRIPTION = "FSL QT5 validation image with Advantech EdgeSense feature"

require wise-paas.inc
