DESCRIPTION = "FSL QT5 image with Advantech EdgeSense feature"

IMAGE_INSTALL_append_mx6 = " packagegroup-wise-paas "

