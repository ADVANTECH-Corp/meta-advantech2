DESCRIPTION = "RPB desktop image with Advantech EdgeSense feature"

require wise-paas.inc
require sdk.inc
