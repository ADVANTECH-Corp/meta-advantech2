DESCRIPTION = "FSL QT5 toolchain with Advantech EdgeSense feature"

require sdk.inc
