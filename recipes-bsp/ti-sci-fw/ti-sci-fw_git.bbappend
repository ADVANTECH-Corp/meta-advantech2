
SYSFW_PREFIX_am62xx-rs10-k3r5-gp = "fs"
SYSFW_PREFIX_am62xx-rs10-k3r5-hs-se = "fs"
SYSFW_PREFIX_am62xx-rs10-k3r5-hs-fs = "fs"
