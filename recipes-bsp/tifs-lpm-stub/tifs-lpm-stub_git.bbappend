
COMPATIBLE_MACHINE = "am62xx-evm|am62xx-lp-evm|am62xx-rs10"
