
# Ninja may fail when path is too long, try to make it a bit shorter
WORKDIR = "${BASE_WORKDIR}/${MULTIMACH_TARGET_SYS}/${PN}/${QT_MODULE_BRANCH}"


