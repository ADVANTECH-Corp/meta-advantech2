
UTILS_append_am335xrom3310a1 = " pru-adc-src"
UTILS_append_am335xrsb4220a1 = " pru-adc-src"
UTILS_append_am335xrsb4221a1 = " pru-adc-src"
UTILS_append_am335xepcr3220a1 = " pru-adc-src"

EXTRA_LIBS_append_am57xxrom7510a1 = " \
    jailhouse-src \
"


