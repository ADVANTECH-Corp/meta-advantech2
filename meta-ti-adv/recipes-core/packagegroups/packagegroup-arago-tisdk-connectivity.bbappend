
WLAN_TI_append_am62xx-rs10 = " \
    wifi-oob \
"
