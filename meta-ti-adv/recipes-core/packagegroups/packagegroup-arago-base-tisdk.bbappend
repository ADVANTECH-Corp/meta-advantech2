RDEPENDS_${PN}_append = "\
    kernel-image-zimage \
    kernel-devicetree \
    kernel-modules \
"


