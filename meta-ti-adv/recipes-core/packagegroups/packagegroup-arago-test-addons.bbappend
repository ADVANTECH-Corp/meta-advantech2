
TEST_ADDONS_TI_append_am335xrom3310a1  = " icss-emac-lld-test"
TEST_ADDONS_TI_append_am335xrsb4220a1  = " icss-emac-lld-test"
TEST_ADDONS_TI_append_am335xrsb4221a1  = " icss-emac-lld-test"
TEST_ADDONS_TI_append_am335xepcr3220a1  = " icss-emac-lld-test"

TEST_ADDONS_TI_append_am57xxrom7510a1 = " \
    osal-test \
    pruss-lld-test \
    icss-emac-lld-test \
"

