
UTILS_append_am57xxrom7510a1 = "tidl-examples-src"

