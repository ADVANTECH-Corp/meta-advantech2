
EXTRA_PKGS_append_am57xxrom7510a1 = " ${TIDL_PKGS}"

