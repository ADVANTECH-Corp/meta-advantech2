
MATRIX_APPS_remove_omap-a15 = " \
    matrix-gui-apps-dual-camera \
    matrix-gui-apps-image-gallery \
"

MATRIX_OPENCL_APPS_remove_omap-a15 = " \
    matrix-video-analytics-opencv-opencl-opengl-demo \
    matrix-machinevision-demo-dlp3dscanner \
"

