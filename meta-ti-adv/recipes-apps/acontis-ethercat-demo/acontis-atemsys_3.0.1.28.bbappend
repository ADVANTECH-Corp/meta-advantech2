
COMPATIBLE_MACHINE = "am335x-evm|am57xx-evm|am335xrom3310a1|am335xrsb4220a1|am335xrsb4221a1|am335xepcr3220a1|am57xxrom7510a1"

