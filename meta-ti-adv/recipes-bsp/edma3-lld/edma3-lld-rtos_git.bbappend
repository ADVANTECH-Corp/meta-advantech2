
PLATFORMLIST_append_ti33x = " \
        am335xrom3310a1 \
        am335xrsb4220a1 \
        am335xrsb4221a1 \
        am335xepcr3220a1 \
"

