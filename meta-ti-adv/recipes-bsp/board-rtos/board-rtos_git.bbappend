
DEPENDS_append_am57xxrom7510a1 = " gpio-lld-rtos \
                              icss-emac-lld-rtos \
                              pruss-lld-rtos \
"

