
do_compile_append_am62xx-rs10() {
        tfa_sign_k3hs
}
