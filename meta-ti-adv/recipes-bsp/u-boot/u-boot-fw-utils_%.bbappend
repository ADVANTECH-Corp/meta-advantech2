
UBOOT_MACHINE_ti33x = "am335x_evm_config"
UBOOT_MACHINE_am57xxrom7510a1 = "am57xx_evm_config"
UBOOT_MACHINE_am57xxrom7510a2 = "am57xx_evm_config"

