
COMPATIBLE_MACHINE = "ti33x|ti43x|am57xx-evm|am57xx-hs-evm|k2g|am57xxrom7510a1"

TARGET_am57xxrom7510a1 = "am57xx-pru0-pruprp-fw.elf am57xx-pru1-pruprp-fw.elf"



