
DEPENDS_append_am57xxrom7510a1 = " pruss-lld-rtos \
"


