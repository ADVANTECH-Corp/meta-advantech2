
MAKEFILES_append_am335xrom3310a1 = " pru-adc"
MAKEFILES_append_am335xrsb4220a1 = " pru-adc"
MAKEFILES_append_am335xrsb4221a1 = " pru-adc"
MAKEFILES_append_am335xepcr3220a1 = " pru-adc"

MAKEFILES_append_am57xxrom7510a1 = " jailhouse \
                                tidl-examples \
"

