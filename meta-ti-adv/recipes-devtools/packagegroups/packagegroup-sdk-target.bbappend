
RDEPENDS_${PN}_remove = " \
   diffutils"


