
DEVICE_NAME_append_am57xxrom7510a1 = "am57xx"

