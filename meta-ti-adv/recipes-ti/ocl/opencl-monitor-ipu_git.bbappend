
COMPATIBLE_MACHINE = "am57xx-evm|am57xx-hs-evm|am57xxrom7510a1"

