
MONITORS_append_am57xxrom7510a1    = " opencl-monitor-ipu"

