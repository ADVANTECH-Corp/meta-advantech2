
ALT_PLATFORM_am57xxrom7510a1 = "AM572X AM571X"

