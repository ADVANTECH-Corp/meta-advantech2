
RDEPENDS_${KERNEL_PACKAGE_NAME}-base_append_am62xx-rs10 = " tifs-lpm-stub"

KERNEL_GIT_URI = "git://github.com/ADVANTECH-Corp/linux-ti.git"
BRANCH = "linux-am623x-staging-08.04.01.03"
SRCREV = "${AUTOREV}"
