
SRC_URI_append_am62xx-rs10 = " \
    file://0001-Customize-hostapd.conf-for-am62xx-sk-wifi-oob-experi.patch \
    file://0002-Customize-wpa_supplicant.conf-for-am62xx-sk-wifi-oob.patch \
"
