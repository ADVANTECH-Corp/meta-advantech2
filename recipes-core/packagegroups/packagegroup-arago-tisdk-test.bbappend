
ARAGO_TI_TEST_remove_omap-a15 = " \
    ti-ipc-test \
    "


