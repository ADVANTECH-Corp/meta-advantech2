
DL_PACKAGES_am62xx-rs10 = " \
    neo-ai-dlr \
    onnxruntime \
    onnxruntime-dev \
"

PYTHON_PACKAGES_am62xx-rs10 = " \
    python3-tensorflow-lite \
