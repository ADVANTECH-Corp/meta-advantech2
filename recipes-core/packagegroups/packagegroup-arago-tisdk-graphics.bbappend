
GRAPHICS_DEMO_am62xx-rs10 = "\
    hmi-demo \
    powervr-graphics \
"
