
UTILS_append_am57xxrom7510a1 = " tidl-examples-dev"
UTILS_append_am57xxrom7510a2 = " tidl-examples-dev"

