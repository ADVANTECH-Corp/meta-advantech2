
DEPLOY_IMAGES_NAME_append_am62xx-rs10 = " ti-fs-firmware-am62x-gp.bin ipc_echo_testb_mcu1_0_release_strip.xer5f wificfg"
