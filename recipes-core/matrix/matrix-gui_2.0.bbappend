
SYSTEMD_AUTO_ENABLE_${PN}_am62xx-rs10 = "disable"
