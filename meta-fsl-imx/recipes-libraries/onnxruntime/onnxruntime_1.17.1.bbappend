FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fix-eigen-sha1.patch"
