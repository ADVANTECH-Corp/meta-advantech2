FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#SRC_URI += "file://skip-automount-for-exfat.patch"

