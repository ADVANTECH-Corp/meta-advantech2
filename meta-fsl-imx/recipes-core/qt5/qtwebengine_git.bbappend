FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0004-chromium_overrides.cpp-Fix-build-with-plugins-and-oz.patch "

