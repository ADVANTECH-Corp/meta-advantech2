FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

do_configure[network] = "1"
