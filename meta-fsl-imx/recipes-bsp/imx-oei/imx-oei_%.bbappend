FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:imx95aom5521a2 = " file://0001-oei-add-imx95-aom5521a2-8G-lpddr5.patch "
