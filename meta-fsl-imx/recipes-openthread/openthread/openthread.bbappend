FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
#ADDON_FILES_DIR:="${THISDIR}/files"
require iw612_ot_src_rev_opts_patches.inc

